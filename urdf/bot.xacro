Commit message: fixed collision values

File: urdf/bot.xacro (robot description, xacro)
@@ -11,5 +11,5 @@
     <collision>
       <geometry>
-        <box size=".15 .10 .05"/>
+        <box size=".07 .09 .12"/>
       </geometry>
     </collision>
